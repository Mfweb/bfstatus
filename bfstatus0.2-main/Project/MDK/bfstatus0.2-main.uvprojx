# Keil uVision project bfstatus0.2-main.uvprojx, settings and files
target BF_Status_Mini (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\Lib\inc;..\..\User;..\..\Libraries\CMSIS;..\..\uCOS-III;..\..\uCOS-III\Cfg;..\..\uCOS-III\Ports;..\..\uCOS-III\Source;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-LIB;..\..\User\APP;..\..\User\USB\lib;..\..\User\USB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/Lib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32fx_delay.c stm32f10x_pwr.c
  group Drives
    ../../User/: mpu6050.c motor.c led.c debug_usart.c DataScope_DP.C nrf24l01.c eeprom.c hmc5883l.c battery.c ms5611.c
  group Modules
    ../../User/: BF_Status_Mini_Conf.h BF_Status_Mini_System.c BF_Status_Mini_Math.c BF_Status_Mini_Global.c BF_Status_Mini_Filter.c BF_Status_Mini_Ctrl.c BF_Status_Mini_RC.c IMU.c
  group User
    ../../User/: stm32f10x_it.c main.c
  group USB
    ../../User/USB/lib/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ../../User/USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c Queue.c
