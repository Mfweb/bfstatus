# Keil uVision project x-quadrotor-mini-remote.uvprojx, settings and files
target x-quadrotor-mini-remote (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: x-quadrotor-mini-remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\Lib\inc;..\..\User;..\..\Libraries\CMSIS;..\..\FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/Lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32fx_delay.c stm32f10x_adc.c
  group FreeRTOS
    ../../FreeRTOS/src/: event_groups.c list.c port.c queue.c tasks.c
    ../../FreeRTOS/src/Mem/: heap_2.c
    ../../FreeRTOS/inc/: FreeRTOSConfig.h
  group User
    ../../User/: stm32f10x_it.c main.c app.c
  group Modules
    ../../User/: oled.c yg.c nrf24l01.c debug_usart.c key_led.c systime.c eeprom.c menu.c battery.c
