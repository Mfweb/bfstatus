# Keil uVision project x-quadrotor-mini-main.uvprojx, settings and files
target x-quadrotor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: x-quadrotor-mini +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Output\main\bin\x-quadrotor-mini.bin ..\..\Output\main\x-quadrotor-mini.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\Lib\inc;..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\Devices\inc;..\..\FreeRTOS\inc;..\..\Libraries\USB\lib;..\..\Libraries\USB\src;..\..\User\x-quadrotor\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003400 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s startup_stm32f10x_md_boot.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/Lib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32fx_delay.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_i2c_boot.c
  group Drives
    ../../User/x-quadrotor/src/: DataScope_DP.C debug_usart.c
    ../../Libraries/Devices/src/: mpu6050.c bmp280.c nrf24l01.c battery.c motor.c led.c
  group Modules
    ../../User/x-quadrotor/inc/: BF_Status_Mini_Conf.h
    ../../User/x-quadrotor/src/: BF_Status_Mini_Param.c BF_Status_Mini_System.c BF_Status_Mini_Global.c BF_Status_Mini_Math.c BF_Status_Mini_Filter.c BF_Status_Mini_Ctrl.c BF_Status_Mini_RC.c IMU.c kalman_filter.c
  group User
    ../../User/x-quadrotor/src/: app.c
    ../../User/: stm32f10x_it.c main.c
  group USB
    ../../Libraries/USB/lib/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ../../Libraries/USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_queue.c usb_regs.c usb_sil.c
  group FreeRTOS
    ../../FreeRTOS/inc/: FreeRTOSConfig.h
    ../../FreeRTOS/src/: list.c port.c queue.c tasks.c event_groups.c
    ../../FreeRTOS/src/Mem/: heap_2.c
  group Bootloader
    ../../User/bootloader/: boot_main.c stm32f10x_it.c
target bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: x-quadrotor-bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,RVDS_ARMCM3_LM3S102
  c include: ..\..\Libraries\Lib\inc;..\..\Libraries\CMSIS;..\..\Libraries\Devices\inc;..\..\FreeRTOS\inc;..\..\Libraries\USB\lib;..\..\Libraries\USB\src;..\..\User\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3400
  memory RVCT9: RAM 0x20000000 size 0x5000
